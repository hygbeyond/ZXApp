# Keil uVision project debug.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: LPC11C14/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: HBTK-X_dbg
  group Source Group 1
    ../app/: debug.c main.c shell.c
