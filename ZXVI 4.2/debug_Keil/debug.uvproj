# Keil uVision project debug.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: NUC130VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: ZXVI_dbg
  group Source Group 1
    ../app/: debug.c main.c shell.c
